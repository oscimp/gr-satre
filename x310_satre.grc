options:
  parameters:
    generate_options: qt_gui
    id: x310_satre
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    comment: |-
      14 bit ADC = 84 dB dynamic range
      => if we only keep 8 bits, drops to 48 dB
      We receive -90 dBm, gain 60 dB => -30 dBm
      Max power is +6 dBm for full scale: with 8 bits,
      +6-48=-42 dBm > -30 dBm so still OK
    scale_factor: '32767'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/220409_08h06_satre_short_5MSps_B210_20dB_50dB.bin
    type: short
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: A
    center_freq0: 70e6
    center_freq1: 70e6
    clock_source0: external
    dev_addr: addr=192.168.10.2
    gain0: '6'
    gain1: '0'
    nchan: '2'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: 70e6
    center_freq1: 70e6
    clock_source0: external
    dev_addr: ''
    gain0: '0'
    gain1: '50'
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_interleave_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [uhd_usrp_source_0, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_interleave_0, '1']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0, '1', qtgui_time_sink_x_0, '1']
- [uhd_usrp_source_0_0, '0', blocks_interleave_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_interleave_0, '1']
- [uhd_usrp_source_0_0, '1', qtgui_freq_sink_x_0, '1']
- [uhd_usrp_source_0_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
