options:
  parameters:
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: SATRE_TV
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '10'
  states: {}
- name: I
  id: variable
  parameters:
    value: int(samp_rate/2.5E6)
  states: {state: disabled}
- name: N
  id: variable
  parameters:
    value: 10000*I
  states: {state: disabled}
- name: ddf
  id: variable_qtgui_range
  parameters:
    start: '-300000'
    step: '1'
    stop: '300000'
    value: '-200000'
  states: {state: disabled}
- name: ddf
  id: variable
  parameters:
    value: '-200000'
  states: {}
- name: df
  id: variable_qtgui_range
  parameters:
    start: '-3000'
    step: '1'
    stop: '3000'
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_2
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_3
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/satre_5MSps_c32.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/gr-satre/code01.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/gr-satre/code02.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/gr-satre/code03.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_2
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/gr-satre/code04.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_3
  id: blocks_file_source
  parameters:
    file: /home/jmfriedt/gr-satre/code05.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*5)
    type: complex
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0_1
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0_2
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0_3
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_1
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_2
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0_3
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: I
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: I
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0_0_0
  id: blocks_repeat
  parameters:
    interp: I
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0_0_1
  id: blocks_repeat
  parameters:
    interp: I
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0_1
  id: blocks_repeat
  parameters:
    interp: I
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_4
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_3
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_0_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_0_0_2
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_0_0_3
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_3
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: fft_vxx_0_4
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(N)
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: df-8944
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: df
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0_0_1
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: df+8944
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0_0_2
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: df-17889
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0_0_3
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: df+17889
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/2/D
    decim: D
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/128
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate/D
    fc: '0'
    fftsize: '32768'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: 5*N
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 1.204e9+ddf
    clock_source0: internal
    gain0: '59'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_mag_0_2, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_mag_0_3, '0', qtgui_time_sink_x_0, '4']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0_0, '0']
- [blocks_file_source_0_1, '0', blocks_interleaved_char_to_complex_0_1, '0']
- [blocks_file_source_0_2, '0', blocks_interleaved_char_to_complex_0_2, '0']
- [blocks_file_source_0_3, '0', blocks_interleaved_char_to_complex_0_3, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_repeat_0_0, '0']
- [blocks_interleaved_char_to_complex_0_0, '0', blocks_repeat_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0_1, '0', blocks_repeat_0_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0_2, '0', blocks_repeat_0_0_0_1, '0']
- [blocks_interleaved_char_to_complex_0_3, '0', blocks_repeat_0_0_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fft_vxx_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_1, '0', fft_vxx_0_0_0_1, '0']
- [blocks_multiply_conjugate_cc_0_2, '0', fft_vxx_0_0_0_2, '0']
- [blocks_multiply_conjugate_cc_0_3, '0', fft_vxx_0_0_0_3, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_repeat_0_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [blocks_repeat_0_0_0, '0', freq_xlating_fft_filter_ccc_0_0_0, '0']
- [blocks_repeat_0_0_0_0, '0', freq_xlating_fft_filter_ccc_0_0_1, '0']
- [blocks_repeat_0_0_0_1, '0', freq_xlating_fft_filter_ccc_0_0_2, '0']
- [blocks_repeat_0_0_1, '0', freq_xlating_fft_filter_ccc_0_0_3, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0_2, '0']
- [blocks_stream_to_vector_0_3, '0', fft_vxx_0_3, '0']
- [blocks_stream_to_vector_0_4, '0', fft_vxx_0_4, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_complex_to_mag_0_1, '0']
- [blocks_vector_to_stream_0_2, '0', blocks_complex_to_mag_0_2, '0']
- [blocks_vector_to_stream_0_3, '0', blocks_complex_to_mag_0_3, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_1, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_2, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0_3, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [fft_vxx_0_0_0_2, '0', blocks_vector_to_stream_0_2, '0']
- [fft_vxx_0_0_0_3, '0', blocks_vector_to_stream_0_3, '0']
- [fft_vxx_0_1, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [fft_vxx_0_2, '0', blocks_multiply_conjugate_cc_0_1, '1']
- [fft_vxx_0_3, '0', blocks_multiply_conjugate_cc_0_2, '1']
- [fft_vxx_0_4, '0', blocks_multiply_conjugate_cc_0_3, '1']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_head_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_multiply_xx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_multiply_xx_0, '1']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_stream_to_vector_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_stream_to_vector_0, '0']
- [freq_xlating_fft_filter_ccc_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [freq_xlating_fft_filter_ccc_0_0_1, '0', blocks_stream_to_vector_0_2, '0']
- [freq_xlating_fft_filter_ccc_0_0_2, '0', blocks_stream_to_vector_0_3, '0']
- [freq_xlating_fft_filter_ccc_0_0_3, '0', blocks_stream_to_vector_0_4, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
